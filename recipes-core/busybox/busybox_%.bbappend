FILESEXTRAPATHS:prepend := "${THISDIR}/busybox:"

SRC_URI += "file://disable_network.cfg"